# Keil uVision project m0_p2.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.2
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: m0_p2
  AfterMake: fromelf -cvf .\m0_p2.axf --vhx --32x1 -o m0_code.hex
  AfterMake: fromelf -cvf .\m0_p2.axf -o m0_code.txt
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\code.sct
  group Source Group 1
    ./: startup_CMSDK_CM0.s main.c exfat.c audio.c
